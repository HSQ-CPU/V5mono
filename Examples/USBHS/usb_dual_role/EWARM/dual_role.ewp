# IAR project dual_role.ewp, settings and files
configuration GD32H7xx (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; USE_USB_FS; USE_USB_HS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Firmware\CMSIS; ..\..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include; ..\..\..\..\Firmware\GD32H7xx_standard_peripheral\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\driver\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\core\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\host\core\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\class\hid\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\host\class\msc\Include; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\common; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\class\hid; ..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\class\msc; ..\..\..\..\Utilities; ..\fat_fs\inc; ..\..\..\..\Utilities\LCD_common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: custom_hid.srec
  ILINK.IlinkOutputFile: dual_core.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c custom_hid_itf.c gd32h7xx_it.c gd32h7xx_usb_hw.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32H7xx_EVAL
    ../../../../Utilities/: gd32h759i_eval.c gd32h759i_eval_exmc_sdram.c gd32h759i_lcd_eval.c
    ../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32H7xx_Peripherals
    ../../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
  group USB_Device
    ../../../../Firmware/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../Firmware/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usb_host.c drv_usbd_int.c drv_usbh_int.c
  group USB_Host
    ../../../../Firmware/GD32H7xx_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USBD_Class
    ../../../../Firmware/GD32H7xx_usbhs_library/device/class/hid/Source/: custom_hid_core.c
  group USBH_Class
    ../../../../Firmware/GD32H7xx_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
