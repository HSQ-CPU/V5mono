# IAR project hid_keyboard.ewp, settings and files
configuration GD32H7xx_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; USE_USB_FS; USE_USBHS0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include; ..\..\..\..\..\Firmware\GD32H7xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\class\hid; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H7xx_USBHS (ARM, debug)
  as the first configuration, except:
  General.FPU2: 6
  ICCARM.CCDefines: GD32H7XX; USE_USB_HS; USE_USBHS0
configuration GD32H7xx_ULPI (ARM, debug)
  as the first configuration, except:
  General.FPU2: 6
  ICCARM.CCDefines: GD32H7XX; USE_USB_HS; USE_USBHS0; USE_ULPI
  ICCARM.CCOptStrategy: 1
  group App
    ../src/: app.c gd32h7xx_it.c gd32h7xx_usb_hw.c gd32h7xx_usb_test.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group GD32H7xx_EVAL
    ../../../../../Utilities/: gd32h759i_eval.c
  group GD32H7xx_Peripherals
    ../../../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
  group USB_Class
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
