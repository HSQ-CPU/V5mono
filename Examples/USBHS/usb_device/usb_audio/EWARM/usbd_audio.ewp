# IAR project usbd_audio.ewp, settings and files
configuration GD32H7xx_USBFS_IIS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: GD32H7XX; USE_USB_FS; USE_USBHS0; USE_USB_AD_SPEAKER; USE_IIS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include; ..\..\..\..\..\Firmware\GD32H7xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\common; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_audio.srec
  ILINK.IlinkOutputFile: usbd_audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H7xx_USBFS_SAI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H7XX; USE_USB_FS; USE_USBHS0; USE_USB_AD_SPEAKER; USE_SAI
  ICCARM.CCOptStrategy: 2
  group App
    ../src/: app.c audio_iis_codec.c audio_sai_codec.c gd32h7xx_it.c gd32h7xx_usb_hw.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group GD32H7xx_EVAL
    ../../../../../Utilities/: gd32h759i_eval.c
  group GD32H7xx_Peripherals
    ../../../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_sai.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
  group USB_Class
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
