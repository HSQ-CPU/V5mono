# Keil uVision project usbd_audio.uvprojx, settings and files
target GD32H7XX(USB_FS_IIS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: usbd_audio +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32H7XX,USE_USB_FS,USE_USBHS0,USE_USB_AD_SPEAKER,USE_IIS
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include;..\..\..\..\..\Firmware\GD32H7xx_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\core\Include;..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\class\audio\Include;..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../src/: app.c audio_iis_codec.c audio_sai_codec.c gd32h7xx_it.c gd32h7xx_usb_hw.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group GD32H7xx_Peripherals
    ../../../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_ctc.c gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c gd32h7xx_sai.c
  group GD32H7xx_EVAL
    ../../../../../Utilities/: gd32h759i_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group USB_Driver
    ../../../../../Firmware/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group Doc
    ../: readme.txt
target GD32H7XX(USB_FS_SAI) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: as above
  output: usbd_audio +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32H7XX,USE_USB_FS,USE_USBHS0,USE_USB_AD_SPEAKER,USE_SAI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.3.0
