# IAR project msc_udisk.ewp, settings and files
configuration GD32H7xx_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H7XX; USE_USB_FS; USE_USBHS0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include; ..\..\..\..\..\Firmware\GD32H7xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\device\class\msc\Include; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32H7xx_usbhs_library\ustd\class\msc; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: msc_udisk.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32H7xx_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H7XX; USE_USB_HS; USE_USBHS0
  ICCARM.CCOptStrategy: 2
configuration GD32H7xx_ULPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: GD32H7XX; USE_USB_HS; USE_USBHS0; USE_ULPI_PHY
  group App
    ../src/: app.c flash_msd.c gd32h7xx_it.c gd32h7xx_usb_hw.c usbd_storage_msd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Doc
    ../: readme.txt
  group GD32H7xx_EVAL
    ../../../../../Utilities/: gd32h759i_eval.c
  group GD32H7xx_Peripherals
    ../../../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_exti.c gd32h7xx_fmc.c gd32h7xx_gpio.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
  group USB_Class
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32H7xx_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32H7xx_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
